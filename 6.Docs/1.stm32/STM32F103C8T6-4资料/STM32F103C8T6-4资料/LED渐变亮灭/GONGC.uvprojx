# Keil uVision project GONGC.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GONGC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\source\wlib\delay;.\source\wlib\SYS;.\source\wlib\USART;.\source\FWLib\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start
    ./source/startup/: cortexm3_macro.s startup_stm32f10x_hd.s
  group user
    ./user/: main.c
  group lib
    ./source/FWLib/src/: stm32f10x_tim.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    ./source/wlib/delay/: delay.c
    ./source/wlib/SYS/: RCC_Configuration.c
    ./source/wlib/USART/: USART_Configuration.c
software components: CMSIS:CORE 5.4.0
